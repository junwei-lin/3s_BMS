# Keil uVision project 3s_BMS_Project.uvproj, settings and files
target 3s_BMS (MCS-51)
  device: STC8A8K64S4A12 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 3s_BMS_Project
  c flags: Optimize=8 SizeSpeed=1
  group Core
    ./: STARTUP.A51
  group User
    ./: main.c
  group Hardware
    D:/资料/自制/三串BMS/软件/3s_BMS_Project/Hardware/GPIO/: gpio.c
  group Lib
    ../Lib/: STC8Ax.h STC8A8K64D4.h
