# Keil uVision project 3s_BMS_Project.uvproj, settings and files
target 3s_BMS (MCS-51)
  device: STC8A8K64S4A12 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 3s_BMS_Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Lib;..\Lib\STC_GPIO;..\Hardware\GPIO
  group Core
    ./: STARTUP.A51
  group User
    ./: main.c main.h
  group Hardware
    ../Hardware/GPIO/: gpio.c gpio.h
    ../Hardware/PIT/: pit.c pit.h
  group Lib
    ../Lib/: STC8Ax.h STC8A8K64D4.h
    ../Lib/STC_GPIO/: stc_gpio.c stc_gpio.h
